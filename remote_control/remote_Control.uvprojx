# Keil uVision project remote_Control.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: remote_Control
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,OS_SUPPORT,GUI_SUPPORT_TOUCH,GUI_USE_ARGB
  c include: .\user;.\Libraries\CMSIS\Device\ST\STM32H7xx\Include;.\Libraries\STM32H7xx_HAL_Driver\Inc;.\Libraries\STM32H7xx_HAL_Driver\Inc\Legacy;.\Libraries\CMSIS\Include;.\Libraries\rtthread nano\3.0.3\include;.\Libraries\rtthread nano\3.0.3\bsp;.\Libraries\rtthread nano\3.0.3\components\finish;.\Libraries\rtthread nano\3.0.3\include\libc;.\user\debug_uart;.\Libraries\rtthread nano\3.0.3\libcpu\arm\cortex-m7;.\user\led;.\user\lcd;.\Libraries\STemWin-latest\inc\5.44;.\Libraries\STemWin-latest\src;.\Libraries\STemWin\Lib;.\Libraries\STemWin\inc;.\Libraries\STemWin\Page;.\user\jpeg_uart;.\user\tim;.\user\adc;.\user\CHInput;.\user\buzz;.\user\freeback;.\user\M8266WIFI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group usr
    ./user/: main.c stm32h7xx_it.c stm32h7xx_hal_conf.h
    ./Libraries/rtthread nano/3.0.3/bsp/: rtconfig.h
    ./user/debug_uart/: bsp_debug_usart.c
    ./user/led/: led.c
    ./user/lcd/: touch.c lcd_drv.c lcd_blk.c
    ./user/tim/: tim.c
    ./user/adc/: adc.c
    ./user/CHInput/: ch_input.c
    ./user/jpeg_uart/: uart.c dma.c wifi_uart.c
    ./user/buzz/: buzz.c
    ./user/freeback/: freeback.c
  group MT8266
    ./user/M8266WIFI/: user_cfg.h brd_cfg.h delay.c M8266HostIf_STM32xx.c M8266WIFI_ops.c test_m8266wifi.c M8266WIFIDrv_STM32H7xx.a sys.c
  group cmsis
    ./Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group periph
    ./Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_mdma.c stm32h7xx_ll_fmc.c stm32h7xx_ll_dma.c stm32h7xx_hal_exti.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_ll_spi.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_ll_adc.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c
  group startup
    ./Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group rtthread/ports
    ./Libraries/rtthread nano/3.0.3/libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
  group rthtread/sourses
    ./Libraries/rtthread nano/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group board
    ./Libraries/rtthread nano/3.0.3/bsp/: board.c
  group GUI
    ./Libraries/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIConf.h GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ./Libraries/STemWin/OS/: GUI_X_OS.c
    ./Libraries/STemWin/Lib/: STemWin_CM7_OS_wc16.a
  group page
    ./Libraries/STemWin/Page/: Lcd_blkDLG.c led_configDLG.c MenuDLG.c Sensor_configDLG.c WindowDLG.c
